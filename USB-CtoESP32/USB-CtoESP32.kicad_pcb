# Repository KUBTSSAvionics/USB-CtoESP32

## KiCad design USB-CtoESP32/USB-CtoESP32.kicad_pcb

Parts:
C1: 1n; C_0603_1608Metric
C2, C4: 10u; C_0603_1608Metric
C3, C5, C6: 0.1u; C_0603_1608Metric
C7: 1u; C_0603_1608Metric
D1, D2: RB160M; D_SOD-123
F1: 0.5-1A; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3: ICSP; PinHeader_2x03_P2.54mm_Horizontal
R1: 1M; R_0603_1608Metric
R2, R3: 5.1k; R_0603_1608Metric
R6, R7: 0.3; R_0603_1608Metric
R11, R13: 10k; R_0603_1608Metric
SW1: RST; SW_SPST_PTS810
SW2: BOOT; SW_SPST_PTS810
U1: LM1117MP-3.3; SOT-223-3_TabPin2
U2: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
Y1: 12MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C3.2, C4.1, C5.2, C6.1, D2.2 (A), J3.5, R11.1, R13.1, U1.2 (VO), U2.4 (V3), U2.16 (VCC)
EN: C7.1, J3.6, R11.2, SW1.2
GND: C1.2, C3.1, C5.1, C6.2, C7.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J3.1, R1.2, R2.2, R3.1, R6.2, R7.1, SW1.1, SW2.2, U1.1 (GND), U2.1 (GND), Y1.2
IO0: J3.4, R13.2, SW2.1
unnamed: C2.2, R6.1
unnamed: C4.2, R7.2
unnamed: D1.2 (A), F1.1
unnamed: C2.1, D1.1 (K), D2.1 (K), U1.3 (VI)
unnamed: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.2
unnamed: C1.1, J1.S1 (SHIELD), R1.1
unnamed: J1.A6 (D+), J1.B6 (D+), U2.5 (UD+)
unnamed: J1.A7 (D-), J1.B7 (D-), U2.6 (UD-)
unnamed: U2.7 (XI), Y1.1
unnamed: U2.8 (XO), Y1.3
RX: J3.3, U2.2 (TXD)
TX: J3.2, U2.3 (RXD)

Notes on the sheet:
BOOTボタンを押さずに書き込めるようにしたかったら、DTR・RTSとEN・IO0の間に論路回路を足す必要あり。↓ 25代から上手くいかなかったため、26代ではやめた。
INPUT OUTPUT DTR RTS EN IO0 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 0

Board: 2 copper layers, 39.5 x 14.4 mm, 24 parts (0 on the bottom side), 18 nets.

## Commit log

2025-11-15 Add files via upload
    回路図作成
2025-11-15 Add files via upload
    ENとIO0を追加
2025-12-19 Add files via upload
    配線終了。
2026-02-10 Add files via upload
    入江さんからのフィードバックを回路図に反映
2026-02-22 Add files via upload
    入江さん承認済み。未配線
2026-03-04 Add files via upload
    配線完了。基板設計完了。
